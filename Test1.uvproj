# Keil uVision project Test1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Test1
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: C:\Keil\ARM\Examples\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.3.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Robot
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: startup_stm32f40_41xxx.s main.c stm32f4xx_it.c system_stm32f4xx.c define.h include.h
  group STM32f4xx
    C:/Keil/ARM/Examples/ST/STM32F4xx_DSP_StdPeriph_Lib_V1.3.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c misc.c
  group Direct_Kinematics
    ./Direct_Kinematics/: Direct_Kinematics.c Direct_Kinematics.h
  group UART
    ./UART/: MYUART.c MYUART.h
  group TIMER
    ./TIMER/: Timer.c Timer.h
  group GPIO
    ./GPIO/: MY_GPIO.c MY_GPIO.h
  group MATRIX
    ./MATRIX/: matrix.h matrix.c
  group QEI
    ./QEI/: qei.c qei.h
